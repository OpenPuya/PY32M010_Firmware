# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: PY32M010x5 Puya
  pack: Puya.PY32Mxxx_DFP.1.0.6
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32M010x5
  c include: ..\Inc;..\..\..\..\..\..\Drivers\BSP\PY32M010xx_Start_Kit;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\CMSIS\Device\PY32Mxxx\Include;..\..\..\..\..\..\Drivers\PY32M010_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ./: startup_py32m010xx.s
    ../Src/: system_py32m010.c
  group Application/User
    ../Src/: main.c py32m010_hal_msp.c py32m010_it.c
  group BSP/py32m010xx_Start_Kit
    ../../../../../../Drivers/BSP/PY32M010xx_Start_Kit/: py32m010xx_Start_Kit.c
  group Drivers/PY32M010_HAL_Driver
    ../../../../../../Drivers/PY32M010_HAL_Driver/Src/: py32m010_hal.c py32m010_hal_rcc.c py32m010_hal_rcc_ex.c py32m010_hal_gpio.c py32m010_hal_pwr.c py32m010_hal_uart.c py32m010_hal_cortex.c py32m010_hal_adc.c py32m010_hal_tim.c py32m010_hal_tim_ex.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.2.0
